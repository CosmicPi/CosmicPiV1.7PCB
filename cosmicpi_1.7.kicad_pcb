# Repository CosmicPi/CosmicPiV1.7PCB

File README.md:

# CosmicPiV1.6
Version 1.6 of the Cosmic Pi, learning the lessons from V2 and going back to something simpler. All the components are now on a single PCB with a snap-off for the SiPM elements. We have also moved to KiCad!

The SiPM's in this design are from Ketek, and we're very happy with the performance. You can find the SiPM datasheet here: https://www.ketek.net/wp-content/uploads/2018/12/KETEK-PM3325-WB-D0-Datasheet.pdf
The SiPM's are also available to purchase retail from their shop (!) - a significant advance over our previous models:
https://www.ketek.net/store/products/pm3325-wb/

The design uses scintillators from Amcrys http://www.amcrys.com/ which are not yet available via a retail outlet, however any BC-408 equivalent scintillator that has diamond polished finish surfaces and dimensions of 200x100x10mm can be mated to the SiPMs with suitable mounting holes.

# What do the signals do?

Shapeout 1 & 2 - Shaped (i.e. amplified and stretched signal from the SiPMs - muon detection waveforms). Not used in current software.

Biasfb 1 & 2 - Feedback on the Vbias supply (i.e. to check that it's the right voltage). Not used in current software.

Inj led 1 & 2 - Light injector LEDs, allowing the operation of the SiPM to be checked (and calibrated) post-assembly. 

Accint 1, 2 - Interrupts from the accelerometer, not really used for anything yet.

Magint 3 - Interrupt from magnetometer, also not used.

Flag, boot0 - Signals to the Raspberry Pi, flag can be set by the STM32 to indicate a particular condition. Boot0 is used to set the boot mode of the STM32, for example when flashing. This doesn't function correctly in this version, it will be updated for V1.7, due to some issues with the STM32 bootloader.

Vbusm otg dm otg dp - Vbus is the USB bus voltage detection line to the STM32 (i.e. in OTG mode, sense incoming voltage), DM and DP are the differential lines for USB communication. Not functional in the current software; note that the USB doesn't power the device.

Swclk, swdio - These are the programming commands for the STM32, based on the ST-Link system. These work fine, used for programming.

## KiCad design cosmicpi_1.7.kicad_pcb

Parts:
C1: 4.7u; C_0805_2012Metric
C2, C5, C6, C7, C8, C11, C12, C14, C15, C17, C18, C23, C27, C29, C34, C35, C55, C79: 100n; C_0603_1608Metric
C3, C4: 22p; C_0603_1608Metric
C9, C10: n.a.; C_1206_3216Metric
C13, C24: 10u; C_0603_1608Metric
C16, C22, C30, C31, C59: 10n; C_0603_1608Metric
C19, C32, C33: 220n; C_0603_1608Metric
C20, C21, C25, C26, C28, C58, C75: 1u; C_1206_3216Metric
C56: 470u; C_Elec_10x10.2
C57: 22u; C_0603_1608Metric
C77, C78: 4.3p; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric
D9, D10: B140; D_SMA
FL1: EMI_Filter_LL_f; IND_744232090
J1: Barrel_Jack_Switch; BarrelJack_Horizontal
J2: SMA; SMA_Molex_73251-1153_EdgeMount_Horizontal
J3: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J6: SWD; PinSocket_1x06_P2.54mm_Vertical_SMD_Pin1Left
J7: Raspberry_Pi_2_3; PinSocket_2x20_P2.54mm_Vertical_SMD
L1: 2.2uH; L_0603_1608Metric
L3: 47nH; L_0603_1608Metric
R1, R3, R4, R10, R70: 20; R_0603_1608Metric
R2, R30, R31, R38, R39, R40, R41, R71: 100k; R_0603_1608Metric
R6, R7: 300; R_0603_1608Metric
R8: 0R; R_0603_1608Metric
R13: 10; R_0603_1608Metric
R22, R23, R24, R25, R26, R27, R28, R29, R34, R35, R36, R37: 10k; R_0603_1608Metric
R32, R33: 330R; R_0603_1608Metric
U1: MCP47CMB22; MSOP-10_3x3mm_P0.5mm
U2: STM32F401RETx; LQFP-64_10x10mm_P0.5mm
U3: L76-M33; LM76-M33
U4: 74HC00; SOIC-14_3.9x8.7mm_P1.27mm
U5: BME280; Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering
U6, U11, U12: LM555; SOIC-8_3.9x4.9mm_P1.27mm
U7: LSM9DS1; LGA-24L_3x3.5mm_P0.43mm
U8: ESP-12F; ESP-12E
U9: MAX991; SOIC-8_3.9x4.9mm_P1.27mm
U10: TPS62163DSG; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm_ThermalVias
U16: LP2985-3.3; SOT-23-5
Y1: 8 MHz; Crystal_SMD_HC49-SD
Y2: 32.768KHz; Crystal_SMD_HC49-SD

Connections:
+3V3: C2.2, C6.1, C7.1, C8.1, C11.1, C12.1, C15.2, C17.2, C18.2, C24.2, C27.1, C28.2, C29.2, C34.1, C35.1, C55.1, C75.1, FL1.2, J6.1, R2.1, R22.2, R23.2, R24.2, R27.2, R30.2, R34.2, R35.2, R36.2, R37.2, R38.2, R40.2, R71.2, U1.1 (VDD), U1.3 (Vref), U2.1 (VBAT), U2.13 (VREF+), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U4.14 (VCC), U5.2 (CSB), U5.6 (VDDIO), U5.8 (VDD), U6.4 (R), U6.8 (VCC), U7.1 (VDDIO), U7.3 (VDDIO), U7.7 (CS_A/G), U7.8 (CS_M), U7.22 (VDD), U7.23 (VDD), U8.3 (EN), U8.8 (VCC), U9.8 (V+), U11.4 (R), U11.8 (VCC), U12.4 (R), U12.8 (VCC), U16.5 (VOUT)
+5V: C57.2, C58.1, D9.1, J7.2 (5V), J7.4 (5V), L1.2, U10.6 (VOS), U16.1 (VIN), U16.3 (ON/~OFF~); also elsewhere on the board
/analog/SIGNAL_OUT_1: U9.3 (+); also elsewhere on the board
/analog/SIGNAL_OUT_2: U9.5 (+); also elsewhere on the board
BIASFB1: U2.20 (PA4); also elsewhere on the board
BIASFB2: U2.21 (PA5); also elsewhere on the board
BOOT0: J7.12 (GPIO18/PWM0), U2.60 (BOOT0)
DAC0: R25.1, U1.4 (Vout0)
DAC1: R26.1, U1.5 (Vout1)
ESP_Boot: J7.5 (SCL/GPIO3), U8.18 (GPIO0)
ESP_Reset: C79.1, J7.3 (SDA/GPIO2), R71.1, U8.1 (~RST)
FLAG: J7.11 (GPIO17), U2.27 (PB1)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C11.2, C12.2, C15.1, C16.2, C17.1, C18.1, C19.2, C20.2, C21.2, C22.1, C23.1, C24.1, C25.2, C26.2, C27.2, C28.1, C29.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C55.2, C56.2, C57.1, C58.2, C59.2, C75.2, C77.2, C78.2, C79.2, D1.1 (K), D2.1 (K), FL1.3, J1.2, J3.5 (GND), J6.3, J7.6 (GND), J7.9 (GND), J7.14 (GND), J7.20 (GND), J7.25 (GND), J7.30 (GND), J7.34 (GND), J7.39 (GND), R1.1, R31.1, R39.1, R41.1, U1.2 (A0), U1.6 (LAT/HVC), U1.7 (GND), U1.8 (A1), U2.12 (VSSA), U2.18 (VSS), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS), U4.7 (GND), U4.12, U4.13, U5.1 (GND), U5.5 (SDO), U5.7 (GND), U6.1 (GND), U7.5 (SDO_A/G), U7.6 (SDO_M), U7.14 (RES), U7.15 (RES), U7.16 (RES), U7.17 (RES)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; also elsewhere on the board
GNDD: C9.2, C10.2, C13.2, C14.2, FL1.4, J2.2 (Ext), U3.1 (GND), U3.10 (GND), U3.12 (GND)
GPSPPS: U2.50 (PA15), U3.4 (1PPS)
GPSRX: U2.16 (PA2), U3.3 (RXD1)
GPSTX: U2.17 (PA3), U3.2 (TDX1)
HVPSU_CL1: U2.9 (PC1); also elsewhere on the board
HVPSU_CL2: U2.10 (PC2); also elsewhere on the board
HVPSU_CS1: U2.39 (PC8); also elsewhere on the board
HVPSU_CS2: U2.38 (PC7); also elsewhere on the board
HVPSU_DIN: U2.11 (PC3); also elsewhere on the board
HVPSU_SCLK: U2.34 (PB13); also elsewhere on the board
INJ_LED1: U2.22 (PA6); also elsewhere on the board
unnamed: C1.1, U2.30 (VCAP1)
unnamed: C3.1, U2.5 (PH0), Y1.1
unnamed: C4.1, U2.6 (PH1), Y1.2
unnamed: C9.1, J2.1 (In), R8.1
unnamed: C10.1, R8.2, R13.1, U3.11 (RF_IN)
unnamed: C13.1, C14.1, FL1.1, U3.6 (V_BCKP), U3.8 (VCC), U3.9 (RESET)
unnamed: C16.1, U6.5 (CV)
unnamed: C19.1, R27.1, U6.6 (THR), U6.7 (DIS)
unnamed: C20.1, R25.2, R28.1
unnamed: C21.1, R26.2, R29.1
unnamed: C22.2, U7.21 (CAP)
unnamed: C23.2, U7.24 (C1)
unnamed: C25.1, R28.2, U9.2 (-)
unnamed: C26.1, R29.2, U9.6 (-)
unnamed: C30.1, U11.5 (CV)
unnamed: C31.1, U12.5 (CV)
unnamed: C32.1, R36.1, U11.6 (THR), U11.7 (DIS)
unnamed: C33.1, R37.1, U12.6 (THR), U12.7 (DIS)
unnamed: C56.1, D10.1, U10.2 (VIN), U10.3 (EN)
unnamed: C59.1, U16.4 (BP)
unnamed: C77.1, U2.3 (PC14), Y2.1
unnamed: C78.1, U2.4 (PC15), Y2.2
unnamed: D1.2 (A), R6.1
unnamed: D2.2 (A), R7.1
unnamed: D9.2, J3.1 (VBUS)
unnamed: D10.2, J1.1
unnamed: J3.2 (D-), R70.1
unnamed: J3.3 (D+), R10.1
unnamed: J3.6 (Shield), R1.2
unnamed: J6.2, R3.2
unnamed: J6.4, R4.2
unnamed: L1.1, U10.7 (SW)
unnamed: L3.1, R13.2
unnamed: L3.2, U3.14 (VCC_RF)
unnamed: R23.1, U4.6, U6.2 (TR)
unnamed: R32.1, U9.1
unnamed: R33.1, U9.7
unnamed: R34.1, U4.8, U11.2 (TR)
unnamed: R35.1, U4.3, U12.2 (TR)
PSU_A_DRIVE: U2.57 (PB5)
PSU_B_DRIVE: U2.26 (PB0)
RX0: J7.8 (GPIO14/TXD), U2.43 (PA10), U8.22 (GPIO1/TXD)
SCL0: R22.1, U1.9 (SCL), U2.61 (PB8), U5.4 (SCK), U7.2 (SCL/SPC)
SDA0: R24.1, U1.10 (SDA), U2.59 (PB7), U5.3 (SDI), U7.4 (SDA/SDI/SDO)
SHAPED_OUT_1: U2.14 (PA0); also elsewhere on the board
SHAPED_OUT_2: U2.15 (PA1); also elsewhere on the board
STRIGOUT_A: R30.1, R31.2, U2.53 (PC12), U6.3 (Q)
STRIGOUT_B: R38.1, R39.2, U2.52 (PC11), U11.3 (Q)
SWCLK: R3.1, U2.49 (PA14)
SWDIO: R4.1, U2.46 (PA13)
TRIG_A: R32.2, U4.1, U4.4, U4.5
TRIG_B: R33.2, U4.2, U4.9, U4.10
TRIG_OUT: R40.1, R41.2, U2.55 (PB3), U12.3 (Q)
TX0: J7.10 (GPIO15/RXD), U2.42 (PA9), U8.21 (GPIO3/RXD)
USB_OTG_DM: R70.2, U2.44 (PA11)
USB_OTG_DP: R10.2, U2.45 (PA12)
_RESET: C5.1, J6.5, J7.7 (GCLK0/GPIO4), R2.2, U2.7 (NRST)
evt_led: R7.2, U2.41 (PA8)
pwr_led: R6.2, U2.23 (PA7)

Notes on the sheet:
Trigger - coincidence and separate channels
GPS module
GPS active antenna
Sensors: acceleration, magnetic field, temperature, humidity
Released under CERN Open Hardware License V. 1.2
Power Supply and Indicator LEDs
Pressure, Humidity and Temperature sensor
Accelerometer & magnetometer
HV bias, SiPMs and pulse signal amplifiers on separate schematic sheet
Red: power on/ GPS lock
Blue: event detection
MCU, DAC, and Raspberry Pi header
choke footprint crossover
USB - check pins for device only mode
component change for V1.7!
Changes for V1.7 schematic Revised USB implementation Input protection diode + cap, added CW power supplies Removed interrupts from I2C devices to simplify routing Revisions to STM32 pins for bootloader and ESP8266 header

Parts:
C36, C37, C38, C39, C40, C42, C62, C63: 1u; C_1206_3216Metric
C41: 10n; C_0603_1608Metric
C43, C44, C49, C50, C53, C54, C64, C65, C66, C67, C70, C72, C74: 100n; C_0603_1608Metric
C45, C46: 30p; C_0603_1608Metric
C47, C48: 100n; C_0805_2012Metric
C51, C52: n.a.; C_1206_3216Metric
C60, C61: 220n; C_0603_1608Metric
C68, C69: 47n; C_0603_1608Metric
C71, C73: 1n; C_0603_1608Metric
C76: 100u; C_1206_3216Metric
D3, D4: BAT46; D_SOD-123F
D5, D6: BAS70-04; SOT-23
D7, D8: LED; LED_0603_1608Metric
FL2: EMI_Filter_LL_f; IND_744232090
J4, J5: Conn_01x04_Male; Ketek_PM3325-WB
J8, J11, J12, J14: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Horizontal
J9, J10, J13, J15: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
L2, L4: 150uH; L_1812_4532Metric
Q1, Q2: BSS123; SOT-23
R5, R9, R14, R15, R21, R49, R57, R59, R61: 10k; R_0603_1608Metric
R11, R12: 15k; R_0603_1608Metric
R16, R17: 806; R_0603_1608Metric
R18, R19: 24.9k; R_0603_1608Metric
R20, R56, R58, R60: 200k; R_0603_1608Metric
R42, R43, R44, R45, R50, R51: 1k; R_0603_1608Metric
R46, R47: 5100; R_0603_1608Metric
R48: 20k; R_0603_1608Metric
R52, R53: 30k; R_0603_1608Metric
R54, R55, R64, R66, R67, R69: 100; R_0603_1608Metric
R62, R63: 300; R_0603_1608Metric
R65, R68: 500k; R_0603_1608Metric
U13: LP2985-3.3; SOT-23-5
U14, U15, U19: AD8039; SOIC-8_3.9x4.9mm_P1.27mm
U17, U18: MAX1932; QFN-12-1EP_4x4mm_P0.8mm

Connections:
+3.3VA: C42.1, C53.1, C54.1, C74.1, C76.1, R48.1, U13.5 (VOUT), U14.8 (V+), U15.8 (V+), U19.8 (V+)
+5V: C62.1, C63.1, C64.1, C65.1, FL2.2, L2.1, L4.1, U17.11 (VIN), U18.11 (VIN); also elsewhere on the board
/analog/SIGNAL_OUT_1: R54.2; also elsewhere on the board
/analog/SIGNAL_OUT_2: R55.2; also elsewhere on the board
BIASFB1: R58.1, R59.2; also elsewhere on the board
BIASFB2: R60.1, R61.2; also elsewhere on the board
GND: C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, FL2.3, J9.1, J10.1, Q1.2 (S), Q2.2 (S), R5.1, R9.1, R14.1, R15.1, R21.1, R57.1, R59.1, R61.1, U17.9 (GND), U18.9 (GND); also elsewhere on the board
GNDREF: C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.1, C44.1, C49.1, C50.1, C53.2, C54.2, C70.2, C72.2, C74.2, C76.2, FL2.4, R49.2, U13.2 (GND), U14.4 (V-), U15.4 (V-), U19.4 (V-)
HVPSU_CL1: U17.3 (CL); also elsewhere on the board
HVPSU_CL2: U18.3 (CL); also elsewhere on the board
HVPSU_CS1: R5.2, U17.12 (CS); also elsewhere on the board
HVPSU_CS2: R9.2, U18.12 (CS); also elsewhere on the board
HVPSU_DIN: R14.2, R15.2, U17.2 (DIN), U18.2 (DIN); also elsewhere on the board
HVPSU_SCLK: U17.1 (SCLK), U18.1 (SCLK); also elsewhere on the board
INJ_LED1: R62.2, R63.2; also elsewhere on the board
unnamed: C36.1, R42.2, R44.1
unnamed: C37.1, R43.2, R45.1
unnamed: C38.1, FL2.1, U13.1 (VIN), U13.3 (ON/~OFF~)
unnamed: C39.1, J13.1, R44.2
unnamed: C40.1, J15.1, R45.2
unnamed: C41.1, U13.4 (BP)
unnamed: C45.1, C47.2, R46.2, U14.1
unnamed: C45.2, D5.3, J13.2, R46.1, U14.2 (-)
unnamed: C46.1, C48.2, R47.2, U15.1
unnamed: C46.2, D6.3, J15.2, R47.1, U15.2 (-)
unnamed: C51.1, R52.2, R54.1, U14.7
unnamed: C51.2, R50.2, R52.1, U14.6 (-)
unnamed: C52.1, R53.2, R55.1, U15.7
unnamed: C52.2, R51.2, R53.1, U15.6 (-)
unnamed: C60.1, R11.2
unnamed: C61.1, R12.2
unnamed: C66.1, D3.1 (K), R16.2, U17.4 (CS+)
unnamed: C67.1, D4.1 (K), R17.2, U18.4 (CS+)
unnamed: C71.1, R65.2, R66.1, U19.1
unnamed: C71.2, R64.2, R65.1, U19.2 (-)
unnamed: C73.1, R68.2, R69.1, U19.7
unnamed: C73.2, R67.2, R68.1, U19.6 (-)
unnamed: D3.2 (A), L2.2, Q1.3 (D)
unnamed: D4.2 (A), L4.2, Q2.3 (D)
unnamed: D7.1 (K), J8.1
unnamed: D7.2 (A), J8.2
unnamed: D8.1 (K), J11.1
unnamed: D8.2 (A), J11.2
unnamed: J9.2, R62.1
unnamed: J10.2, R63.1
unnamed: J4.3, J4.4, J12.1
unnamed: J4.1, J4.2, J12.2
unnamed: J5.3, J5.4, J14.1
unnamed: J5.1, J5.2, J14.2
unnamed: Q1.1 (G), U17.10 (GATE)
unnamed: Q2.1 (G), U18.10 (GATE)
unnamed: R11.1, U17.8 (COMP)
unnamed: R12.1, U18.8 (COMP)
unnamed: R18.1, R20.1, R21.2, U17.7 (FB)
unnamed: R18.2, U17.6 (DACOUT)
unnamed: R19.1, R56.1, R57.2, U18.7 (FB)
unnamed: R19.2, U18.6 (DACOUT)
SHAPED_OUT_1: R66.2; also elsewhere on the board
SHAPED_OUT_2: R69.2; also elsewhere on the board
TAP1: C47.1, R50.1, R64.1
TAP2: C48.1, R51.1, R67.1
VBIAS1: C68.1, R16.1, R20.2, R42.1, R58.2, U17.5 (CS-)
VBIAS2: C69.1, R17.1, R43.1, R56.2, R60.2, U18.5 (CS-)
V_OFFSET: C43.2, C44.2, C49.2, C50.2, C70.1, C72.1, D5.1, D5.2, D6.1, D6.2, R48.2, R49.1, U14.3 (+), U14.5 (+), U15.3 (+), U15.5 (+), U19.3 (+), U19.5 (+)

Notes on the sheet:
Analog Channel 1
Analog Channel 2
Analog PSU - regulated and well filtered
Offset voltage
1.1 V
HV Bias 1 20-40 V
HV Bias 2 20-40 V
Released under CERN Open Hardware License V. 1.2
Shaping stage for slow pulses
LEDs for light injection
Cockcroft Walton Power supplies added. These will be DNP in this production run.

Board: 4 copper layers, 127.7 x 183.3 mm, 208 parts (0 on the bottom side), 130 nets.

Other parts of the board:
H1, H2, H3, H3#2: MountingHole_3.7mm

File CosmicPiBom1point7extended.xlsx:

Id | Designator | Supplier | SKU | Manufacturer | MPN | Quantity | Alternative | Comments | Package | Value | Voltage | Tolerance | Wattage
1 | D1,D2 | Farnell | 2426212 | Kingbright | KPH-1608QBC-D | 2 |  |  | LED_0603_1608Metric | LED
2 | D8, D7 | RS | 692-1219P | Lite-On | LTST-S270KGKT | 2 |  |  | LED_0603_1608Metric | LED
2 | D10,D9 | RS | 815-1119P | Vishay | B140-E3/61T | 2 |  |  | D_SMA | B140-E3
3 | Y1 | RS | 813-6031P | RALTRON | QC5CA8.00000F12B23R | 1 |  |  | Crystal_SMD_5032-4Pin_5.0x3.2mm | 8 MHz
4 | Y2 | RS | 187-5908P | Abracon | ABS07-32.768kHz-6-4-T | 1 | 9HT10-32.768KDZF-T |  | Crystal_SMD_EuroQuartz_EQ161-2Pin_3.2x1.5mm | 32.768KHz
5 | C56 | RS | 537-0118P | Panasonic | EEEFT1E471AP | 1 |  |  | C_Elec_10x10.2 | 470u
6 | U8 | DNP | DNP | DNP | DNP | 1 | DNP | Do Not Place | ESP-12E | ESP-12F
7 | R71,R41,R2,R31,R40,R39,R38,R30 | RS | 678-9673 | Vishay | CRCW0603100KFKEA | 8 | CRCW0603100KJNEAIF |  | R_0603_1608Metric | 100k |  | 0.01 | 100mW
8 | C79,C27,C29,C34,C35,C64,C74,C14,C55,C54,C53,C50,C49,C44,C43,C66,C2,C5,C6,C7,C8,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 | RS | 669-8767 | Yageo | CC0603KRX7R9BB104 | 31 |  |  | C_0603_1608Metric | 100n | 50V
9 | C78,C77 | RS | 179-5270 | TDK | CGA3E2C0G2A040C080AA | 2 |  |  | C_0603_1608Metric | 4.3p
10 | U5 | Digikey | 828-1063-1-ND | Bosch | BME280 | 1 | N/A |  | Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering | BME280
11 | J7 | Farnell | 2847928 | Multicomp | 2214SM-20G-75-PCR | 1 |  |  | PinSocket_2x20_P2.54mm_Vertical_SMD | Raspberry_Pi_2_3
12 | U18,U17 | Digikey | MAX1932ETC+TCT-ND | Maxim | MAX1932ETC+ | 2 |  |  | QFN-12-1EP_4x4mm_P0.8mm | MAX1932
15 | J5,J4 |  |  |  | PM3325-WB | 2 | N/A | Customer supplied | Ketek_PM3325-WB | Conn_01x04_Male
16 | R11,R12 | RS | 134-5446 | TE Connectivity | CRG0603F15K | 2 |  |  | R_0603_1608Metric | 15k
17 | FL1,FL2 | RS | 770-7133 | Wurth | 744235220 | 2 | 123-4666 | Alternative is RS-PRO | IND_744232090 | EMI_Filter_LL_f
18 | U14,U19,U15 | RS | 912-7432 | Analog Devices | AD8039ARZ | 3 |  |  | SOIC-8_3.9x4.9mm_P1.27mm | AD8039
19 | R70,R10,R3,R4,R1 | RS | 105-8469 | Panasonic | ERJ3EKF20R0V | 5 |  |  | R_0603_1608Metric | 20
20 | C1 | RS | 766-1037 | Samsung | CL21B475KOFNNNG | 1 | C0805C475K3PACTU |  | C_0805_2012Metric | 4.7u | 16V | 0.1
21 | D5,D6 | RS | 687-2779 | Taiwan Semi | BAS70-04 RF | 2 | BAS70-04LT1G |  | SOT-23 | BAS70-04
22 | R46,R47 | RS | 179-9597 | Panasonic | ERA3AEB512V | 2 | NTR06B5101CTR1KF |  | R_0603_1608Metric | 5100
23 | J14,J8,J11,J12 | RS | 701-9773 | Preci-Dip | 800-80-002-20-001101 | 4 | 830-80-002-20-001101 |  | PinHeader_1x02_P2.54mm_Horizontal | Conn_01x02_Male
24 | J9,J10,J13,J15 | RS | 766-6604 | Samtec | CES-102-01-T-S | 4 |  |  | PinHeader_1x02_P2.54mm_Vertical | Conn_01x02_Female
25 | D4,D3 | RS | 792-0787 | Nexperia | BAT46WH | 2 |  |  | D_SOD-123F | BAT46
26 | J2 | RS | 759-5299 | Molex | 73251-1150 | 1 |  |  | SMA_Molex_73251-1153_EdgeMount_Horizontal | SMA
27 | C57 | RS | 915-9114 | TDK | C1608X5R1A226M080AC | 1 | GRM188R61A226ME15D |  | C_0603_1608Metric | 22u
28 | C30,C31,C41,C59,C22,C16 | RS | 616-9537 | Yageo | CC0603KRX7R9BB103 | 6 |  |  | C_0603_1608Metric | 10n
29 | C32,C33,C61,C60,C19 | Farnell | 722250 | Yageo | CC0603KRX7R8BB224 | 5 |  |  | C_0603_1608Metric | 220n
30 | C46,C45 | RS | 815-1531 | Murata | GRM1885C2A300JA01D | 2 |  |  | C_0603_1608Metric | 30p
31 | C3,C4 | RS | 773-8446 | Syfer | 0603Y1000220JCT | 2 | CL10C220FB8NNND |  | C_0603_1608Metric | 22p
32 | C71,C73 | Farnell | 1828913 | Murata | GRM1885C1H102FA01D | 2 | GRM1881X1H102JA01D |  | C_0603_1608Metric | 1n
33 | C68,C69 | Farnell | 1414642 | Kemet | C0603C472K5RACTU | 2 | C0603C473K5RACAUTO |  | C_0603_1608Metric | 47n
34 | C13,C24 | RS | 884-7166 | Murata | GRM188B31A106ME69D | 2 |  |  | C_0603_1608Metric | 10u
35 | C47,C48 | Farnell | 2773209 | Kemet | C0805C104M3RACTU | 2 |  |  | C_0805_2012Metric | 100n
36 | C9,C10,C52,C51 | DNP | DNP | DNP | DNP | 4 | DNP | DNP | C_1206_3216Metric | n.a.
37 | C20,C75,C25,C62,C63,C58,C21,C28,C26,C40,C37,C38,C36,C39,C42 | Farnell | 9227873 | Kemet | C1206C105Z3VACTU | 15 |  |  | C_1206_3216Metric | 1u
38 | C76 | RS | 172-1612 | Taiyo Yuden | JMK316BBJ107MLHT | 1 |  |  | C_1206_3216Metric | 100u
39 | J1 | RS | 122-4879 | Wurth | 694106301002 | 1 |  |  | BarrelJack_Horizontal | Barrel_Jack_Switch
40 | J6 | Farnell | 2847171 | Multicomp | 2211SM-06G-B1-TB | 1 | TSM-106-01-T-SV |  | PinSocket_1x06_P2.54mm_Vertical_SMD_Pin1Left | SWD
41 | J3 | Farnell | 2293836 | Molex | 105017-0001 | 1 |  |  | USB_Micro-B_Molex-105017-0001 | USB_B_Micro
42 | U3 | RS | 908-4108 | Quectel | L76-M33 | 1 | L70B-M39 |  | LM76-M33 | L76-M33
43 | L3 | RS | 496-0978 | EPCOS | B82496C3470J000 | 1 |  |  | L_0603_1608Metric | 47nH
44 | L1 | RS | 604-1489 | TDK | MLZ1608A2R2MT | 1 |  | BRL1608T2R2M | L_0603_1608Metric | 2.2uH
45 | L4,L2 | Farnell | 1612672 | Bourns | CM453232-151KL | 2 |  |  | L_1812_4532Metric | 150uH
46 | U7 | Farnell | 2532383RL | ST | LSM9DS1TR | 1 |  |  | LGA-24L_3x3.5mm_P0.43mm | LSM9DS1
47 | U2 | RS | 110-6614 | ST | STM32F401RET6 | 1 |  |  | LQFP-64_10x10mm_P0.5mm | STM32F401RETx
48 | U1 | Digikey | MCP47CMB12-E/UN-ND | Microchip | MCP47CMB12-E/UN | 1 | MCP47CMB22-E/UN |  | MSOP-10_3x3mm_P0.5mm | MCP47CMB22
49 | U4 | RS | 798-8985 | DiodesZetex | 74HC00S14-13 | 1 | 74HC00D |  | SOIC-14_3.9x8.7mm_P1.27mm | 74HC00
50 | U6,U11,U12 | RS | 121-8948 | TI | TLC555ID | 3 |  |  | SOIC-8_3.9x4.9mm_P1.27mm | LM555
51 | U9 | Farnell | 2515037 | Maxim | MAX991ESA+ | 1 |  |  | SOIC-8_3.9x4.9mm_P1.27mm | MAX991
52 | U10 | RS | 825-6949 | TI | TPS62163DSGT | 1 | TPS62163DSGR |  | WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm_ThermalVias | TPS62163DSG
53 | Q2,Q1 | RS | 671-0321 | On Semiconductor | BSS123 | 2 | BSS123W |  | SOT-23 | BSS123
54 | U13,U16 | Farnell | 1469134 | TI | LP2985AIM5-3.3/NOPB | 2 | LP2985IM5-3.3/NOPB |  | SOT-23-5 | LP2985-3.3
55 | R33,R32 | Farnell | 2331995 | TE | CRG0603F330R | 2 |  |  | R_0603_1608Metric | 330R
56 | R57,R49,R23,R59,R21,R15,R14,R61,R9,R5,R36,R35,R34,R22,R37,R29,R28,R27,R26,R25,R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 | Farnell | 1469748RL | Vishay | CRCW060310K0FKEA | 21 |  |  | R_0603_1608Metric | 10k
57 | R48 | Farnell | 1670194 | Panasonic | ERA3AEB203V | 1 |  |  | R_0603_1608Metric | 20k
58 | R50,R51,R45,R44,R43,R42 | RS | 213-2266 | TE | CRG0603F1K0 | 6 |  |  | R_0603_1608Metric | 1k
59 | R52,R53 | RS | 179-9591 | Panasonic | ERA3AEB303V | 2 |  |  | R_0603_1608Metric | 30k
60 | R54,R55,R64,R66,R67,R69 | RS | 176-3495 | Panasonic | ERJ3EKF1000V | 6 |  |  | R_0603_1608Metric | 100
61 | R56,R58,R60,R20 | RS | 678-9967 | Vishay | CRCW0603200KFKEA | 4 |  |  | R_0603_1608Metric | 200k
62 | R63,R7,R62,R6 | RS | 679-0172 | Vishay | CRCW0603300RFKEA | 4 |  |  | R_0603_1608Metric | 300
63 | R65,R68 | Farnell | 2138570 | Vishay | CRCW0603510KFKEA | 2 | CRCW0603499KFKEA |  | R_0603_1608Metric | 500k
64 | R19,R18 | Farnell | 1469785 | Vishay | CRCW060324K9FKEA | 2 |  |  | R_0603_1608Metric | 24.9k
65 | R17,R16 | RS | 106-2936 | Panasonic | ERJP03F8060V | 2 |  |  | R_0603_1608Metric | 806
66 | R13 | Farnell | 1469751 | Vishay | CRCW060310R0FKEA | 1 | CR0603-FX-10R0ELF |  | R_0603_1608Metric | 10
67 | R8 | Farnell | 2616741 | Vishay | CRCW06030000Z0EB | 1 |  |  | R_0603_1608Metric | 0R

## Code that names these connections

File cosmicpiv1point7.ioc (part):

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Mcu.Name=STM32F401R(D-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F401RETx
PA0-WKUP.GPIOParameters=GPIO_Label
PA0-WKUP.GPIO_Label=shaped_out_1
PA0-WKUP.Signal=ADCx_IN0
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=shaped_out_2
PA1.Signal=ADCx_IN1
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.Mode=Device_Only
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=Device_Only
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=GPSPPS
PA15.Signal=S_TIM2_CH1_ETR
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=gpsrx
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=gpstx
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=biasfb1
PA4.Signal=ADCx_IN4
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=biasfb2
PA5.Signal=ADCx_IN5
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=inj_led
PA6.Signal=S_TIM3_CH1
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=pwr_led
PA7.Signal=GPIO_Output
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=evt_led
PA8.Signal=GPIO_Output
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=flag
PB1.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=hvpsu_sclk
PB13.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=trig_out
PB3.Signal=S_TIM2_CH2
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=hvpsu_cl1
PC1.Signal=GPIO_Input
PC11.GPIOParameters=GPIO_Label
PC11.GPIO_Label=strigout_b
PC11.Signal=GPIO_Input
PC12.GPIOParameters=GPIO_Label
PC12.GPIO_Label=strigout_a
PC12.Signal=GPIO_Input
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=hvpsu_cl2
PC2.Signal=GPIO_Input
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=hvpsu_din
PC3.Signal=GPIO_Output
PC7.GPIOParameters=GPIO_Label
PC7.GPIO_Label=hvpsu_cs2
PC7.Signal=GPIO_Output
PC8.GPIOParameters=GPIO_Label
PC8.GPIO_Label=hvpsu_cs1
PC8.Signal=GPIO_Output
PH0\ -\ OSC_IN.Mode=HSE-External-Oscillator
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PH1\ -\ OSC_OUT.Mode=HSE-External-Oscillator
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=20000000
RCC.SYSCLKFreq_VALUE=84000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2019-08-25 First upload - schematic only
    Schematic updates for the V1.7 production run.
    Changes to:
    USB connection (dropped OTG, slave device only, 5V power now connected)
    Dropped interrupts from I2C devices to facilitate routing
    Swapped to BME280 temperature, pressure and humidity sensor
    Added input protection diode and increased capacitor on DC input to allow use of AC supplies
2019-08-26 added esp header and cw psu
    footpints and board layouts to do
2019-09-03 updated a little
2019-09-15 footprints corrected, routing in progress
2019-09-29 finished place and route
    BOM still needs updating!
2019-09-29 updated schematic
2019-11-01 added BOM for 1.7

Notices in the files:
cosmicpi_1.7.kicad_pcb:
Released under the CERN Open Hardware License V1.2
